Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-05-21T12:24:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri May 21 12:24:05 2021 * Host: JRLAP21HP * Database: C:\Users\JAMESR~1\AppData\Local\Temp\{FF9DF8E6-27F3-4F0F-ABE1-1C8D2A8AADE4}\ifc * Database version: 5507 * Database creation date: Fri May 21 12:24:03 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri May 21 12:24:03 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri May 21 12:24:03 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowTerminal: Milano Halo Ø60 16LED 2.7k C3, Milano Halo:Milano Halo Ø60 16LED 2.7k C3:312536
In: Level 0
Type - Material: RAL 9006 Aluminium, Toughened glass
Pset_DistributionFlowElementCommon - Reference: Milano Halo Ø60 16LED 2.7k C3
